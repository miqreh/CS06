# IAR project Project.ewp, settings and files
configuration STM32L4xx_Nucleo_SPWF01 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476RG ST STM32L476RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: SPWF01; CONSOLE_UART_ENABLED; USE_HAL_DRIVER; STM32L476xx; USE_STM32L4XX_NUCLEO; USART_PRINT_MSG
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_SPWF0xSy\Utils; ..\..\..\..\..\..\Middlewares\ST\STM32_SPWF0xSy\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32L4xx_Nucleo; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDW0xx1
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32l476xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32L4xx_Nucleo_SPWF04_UART (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SPWF04; CONSOLE_UART_ENABLED; USE_HAL_DRIVER; STM32L476xx; USE_STM32L4XX_NUCLEO; USART_PRINT_MSG
configuration STM32L4xx_Nucleo_SPWF04_SPI (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SPWF04; USE_HAL_DRIVER; STM32L476xx; USE_STM32L4XX_NUCLEO; USART_PRINT_MSG
  ICCARM.CCOptLevel: 3
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32L4xx-Nucleo
    ../../../../../../Drivers/BSP/STM32L4xx_Nucleo/: stm32l4xx_nucleo.c
  group Drivers/CMSIS
    ../../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_gpio.c stm32l4xx_hal_lptim.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c
  group Drivers/X-NUCLEO-IDW0xx1
    ../../../../../../Drivers/BSP/X-NUCLEO-IDW0xx1/: stm32_spwf_wifi.c
  group Example/EWARM
    ./: startup_stm32l476xx.s
  group Example/User
    ../../Src/: console.c main.c stm32_xx_hal_msp.c stm32_xx_it.c
  group Middlewares/STM32_SPWF0xSy
    ../../../../../../Middlewares/ST/STM32_SPWF0xSy/: wifi_interface.c wifi_module.c wifi_module_spi.c wifi_module_uart_01.c wifi_module_uart_04.c
  group Middlewares/Utils
    ../../../../../../Middlewares/ST/STM32_SPWF0xSy/Utils/: event_buffer.c ring_buffer.c spwf04WiFi.c wifi_globals.c
