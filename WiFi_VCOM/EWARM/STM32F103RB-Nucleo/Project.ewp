# IAR project Project.ewp, settings and files
configuration STM32F1xx_NUCLEO_SPWF01 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: CONSOLE_UART_ENABLED; SPWF01; USE_HAL_DRIVER; STM32F103xB; USE_STM32F1xx_NUCLEO; USART_PRINT_MSG; WIFI_USE_VCOM
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_SPWF0xSy\Utils; ..\..\..\..\..\..\Middlewares\ST\STM32_SPWF0xSy\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include; ..\..\..\..\..\..\Drivers\STM32F1xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32F1xx_Nucleo; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDW0xx1
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32F1xx_NUCLEO_SPWF04_UART (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CONSOLE_UART_ENABLED; SPWF04; USE_HAL_DRIVER; STM32F103xB; USE_STM32F1xx_NUCLEO; USART_PRINT_MSG; WIFI_USE_VCOM
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32F1xx_Nucleo
    ../../../../../../Drivers/BSP/STM32F1xx_Nucleo/: stm32f1xx_nucleo.c
  group Drivers/CMSIS
    ../../Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../../../../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c
  group Drivers/X-NUCLEO-IDW0xx1
    ../../../../../../Drivers/BSP/X-NUCLEO-IDW0xx1/: stm32_spwf_wifi.c
  group Example/EWARM
    ./: startup_stm32f103xb.s
  group Example/User
    ../../Src/: console.c main.c stm32_xx_hal_msp.c stm32_xx_it.c
  group Middlewares/STM32_SPWF0xSy
    ../../../../../../Middlewares/ST/STM32_SPWF0xSy/: wifi_interface.c wifi_module.c wifi_module_uart_01.c wifi_module_uart_04.c
  group Middlewares/Utils
    ../../../../../../Middlewares/ST/STM32_SPWF0xSy/Utils/: event_buffer.c ring_buffer.c wifi_globals.c
