# Keil uVision project Project.uvprojx, settings and files
target STM32F103RB_Nucleo_SPWF01 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103VB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103RB_Nucleo
  AfterMake: fromelf --bin -o STM32F103RB_Nucleo\STM32F103RB_Nucleo.bin STM32F103RB_Nucleo\STM32F103RB_Nucleo.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,USE_STM32F1xx_NUCLEO,USART_PRINT_MSG,WIFI_USE_VCOM,SPWF01,CONSOLE_UART_ENABLED
  c misc: --C99
  c include: ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\..\..\..\..\Drivers\BSP\STM32F1xx_Nucleo;..\..\..\..\..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDW0xx1;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_SPWF0xSy\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_SPWF0xSy\Utils
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Drivers\BSP\STM32F1xx_Nucleo
    ../../../../../../Drivers/BSP/STM32F1xx_Nucleo/: stm32f1xx_nucleo.c
  group Drivers\CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group WiFi_VCOM\MDK-ARM
    ./: startup_stm32f103xb.s
  group Drivers\STM32F1xx_HAL_Driver
    ../../../../../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c
  group Drivers\BSP\X-NUCLEO-IDW0xx1
    ../../../../../../Drivers/BSP/X-NUCLEO-IDW0xx1/: stm32_spwf_wifi.c
  group Applications\WiFi_VCOM\Src
    ../../Src/: main.c stm32_xx_it.c stm32_xx_hal_msp.c console.c
  group Middlewares\STM32_SPWF0xSy
    ../../../../../../Middlewares/ST/STM32_SPWF0xSy/: wifi_interface.c wifi_module.c wifi_module_uart_01.c wifi_module_uart_04.c
  group Middlewares\Utils
    ../../../../../../Middlewares/ST/STM32_SPWF0xSy/Utils/: wifi_globals.c ring_buffer.c event_buffer.c
target STM32F103RB_Nucleo_SPWF04_UART (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103VB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: as above
  output: STM32F103RB_Nucleo
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,USE_STM32F1xx_NUCLEO,USART_PRINT_MSG,WIFI_USE_VCOM,SPWF04,CONSOLE_UART_ENABLED
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
