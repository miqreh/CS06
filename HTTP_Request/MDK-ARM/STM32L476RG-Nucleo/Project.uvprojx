# Keil uVision project Project.uvprojx, settings and files
target STM32L476XX_Nucleo_SPWF01 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.2.0
  cpu: IROM(0x08000000,0x00100000) IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32L476XX_Nucleo
  AfterMake: fromelf --bin -o STM32L476XX_Nucleo\STM32L476XX_Nucleo.bin STM32L476XX_Nucleo\STM32L476XX_Nucleo.axf
  c flags: OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx,USE_STM32L4XX_NUCLEO,USART_PRINT_MSG,SPWF01,CONSOLE_UART_ENABLED
  c misc: --C99 --gnu
  c include: ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\BSP\STM32L4xx_Nucleo;..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDW0xx1;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_SPWF0xSy\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_SPWF0xSy\Utils
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Drivers\BSP\STM32L4xx_Nucleo
    ../../../../../../Drivers/BSP/STM32L4xx_Nucleo/: stm32l4xx_nucleo.c
  group Drivers\CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group Client_Socket\MDK-ARM
    ./: startup_stm32l476xx.s
  group Drivers\BSP\X-NUCLEO-IDW01M1
    ../../../../../../Drivers/BSP/X-NUCLEO-IDW0xx1/: stm32_spwf_wifi.c
  group Applications\Client_Socket\Src
    ../../Src/: main.c stm32_xx_it.c console.c stm32_xx_hal_msp.c
  group Drivers\STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_lptim.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_dma.c stm32l4xx_hal_spi.c
  group Middlewares\STM32_SPWF0xSy
    ../../../../../../Middlewares/ST/STM32_SPWF0xSy/: wifi_interface.c wifi_module.c wifi_module_spi.c wifi_module_uart_01.c wifi_module_uart_04.c
  group Middlewares\Utils
    ../../../../../../Middlewares/ST/STM32_SPWF0xSy/Utils/: wifi_globals.c spwf04WiFi.c ring_buffer.c event_buffer.c
target STM32L476XX_Nucleo_SPWF04_UART (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.2.0
  cpu: as above
  output: STM32L476XX_Nucleo
  AfterMake: as above
  c flags: OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx,USE_STM32L4XX_NUCLEO,USART_PRINT_MSG,SPWF04,CONSOLE_UART_ENABLED
  c misc: --C99 --gnu
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
target STM32L476XX_Nucleo_SPWF04_SPI (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.2.0
  cpu: as above
  output: STM32L476XX_Nucleo
  AfterMake: as above
  c flags: OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx,USE_STM32L4XX_NUCLEO,USART_PRINT_MSG,SPWF04
  c misc: --C99 --gnu
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
